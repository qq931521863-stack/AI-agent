# Keil uVision project xpPFC431_48.uvprojx, settings and files
target APP_A (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8008000-0x8012FFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: APP_A +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,APP_SLOT_A_BUILD
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../AppUser;../pfc;../Math_Lib/inc;../User;../User/UartUpgrade;../Driver/USART;../Service/pfc_safe;../Service/Flash_Internal;../Service/CRC
  memory RVCT4: ROM 0x8008000 size 0xb000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_comp.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_iwdg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group AppUser
    ../AppUser/: user_sample.c MODBUS_SLAVE.c ConsoleSlow.c ConsoleMid.c ConsoleFast.c ProtectionPFC.c
    ../pfc/: pfc_v6.lib
  group User
    ../User/: upgrade_app.c UpgradeDebugLog.c Timer_pro.c Uart_Rec_Analysis.c UartFrameHelper.c InquireDevMsg.c UpgradeMsgSaveFunctionDf.c AppSlotValidate.c UartPort.c
    ../User/UartUpgrade/: UartRecUpgradeCmdRetuenDf.c
    ../Driver/USART/: usart3_debug.c
  group Service
    ../Service/pfc_safe/: PfcSafeHw.c PfcSafeAppBridge.c
    ../Service/Flash_Internal/: flash_internal.c mx25L1606E.c
    ../Service/CRC/: crc16.c
target APP_B (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8013000-0x801DFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: APP_B +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,APP_SLOT_B_BUILD
  c include: as above
  memory RVCT4: ROM 0x8013000 size 0xb000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2800
target NO_BOOT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.1.0
  cpu: as above
  output: APP_A +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,APP_SLOT_A_BUILD,NO_BOOT
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2800
software components: CMSIS:CORE 5.4.0
